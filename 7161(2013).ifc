Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-08T12:19:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 08 12:19:29 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{6EE9B4E4-32C5-4650-85A9-8F045E5A19AE}\ifc * Database version: 5507 * Database creation date: Fri Jun 08 12:19:28 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 08 12:19:28 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 08 12:19:28 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: 7161 Shower faucet, 7161(2013):7161 Shower faucet:373909
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Pset_ManufacturerTypeInformation - ModelReference: 7161; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7161 Shower faucet
